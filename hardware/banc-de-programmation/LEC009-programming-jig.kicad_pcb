# Repository LECTIX/LEC009002-D-tecteur-IR

File README.md:

# LEC009002 - Détecteur IR
Fichiers sources pour le produit LEC009002

## Description du produit

- Distance de détection réglable jusqu’à 10 cm
- Fonctionne même à la lumière du jour!
- Temporisation à la désactivation pour éviter des réactivations intempestives.
- 2 modes de fonctionnements :

1. **Mode direct (1 capteur)** le relais est commuté lorsqu’un objet se trouve en face du capteur. Le relais est relâché lorsqu’il n’y a plus d’obstacles devant le capteur.
2. **Mode bistable (2 capteurs)** Le relais est relâché lorsqu’un objet passe devant le second capteur.

## Utiliser les fichiers sources pour fabriquer le produit

Grâce aux fichiers sources publiés ici, vous pouvez être en mesure de faire fabriquer ce produit par un sous traitant.

**ATTENTION** ce produit est un **produit complexe à fabriquer** et nécessite notamment une programmation afin de pouvoir fonctionner. Vous devez pour cela posséder le programmateur et programmer vous même la carte. Cette étape peut nécessiter des connaissances techniques, si nécessaire, nous vous encourrageons à vous rapprocher d'un club.

**Remarque** ce produit est composé d'une carte mère, de 2 nappes de cable IDC 6 pin, et de 2 capteurs. Ce dossier permet uniquement de faire fabriquer la carte mère et les capteurs, vous devrez vous fournir les autres composants sur un site de revente (amazon, aliexpress, mouser, ...).

**Remarque 2** vous avez le choix entre 1 capteur coudé ou 1 capteur classique. Notez cependant que pour le capteur classique, le sous traitant JLCPCB n'est pas capable de souder le capteur sur le côté du PCB, vous devrez donc opter pour le capteur coudé si vous ne souhaitez pas souder vous même.

### Faire fabriquer chez un sous traitant

Il est aujourd'hui possible de faire fabriquer à moindre cout des cartes électroniques. Nous recommendons [JLCPCB](https://jlcpcb.com/) si vous voulez aller au moins cher. Si vous préférez un acteur européen, [eurocircuits](https://www.eurocircuits.com/) est un des acteurs reconnus.

1. Télécherger les sources de ce produit en cliquant sur le bouton `Code`, puis `Download ZIP`.
1. Décompresser le dossier.
1. Les fichiers pour la fabrication se trouvent dans le répertoire `hardware/prod`.
1. Se connecter sur [https://cart.jlcpcb.com/quote](https://cart.jlcpcb.com/quote)
1. Cliquer sur le bouton `Add gerber file` et sélectionner le fichier `gerbers.zip`.
1. Sélectionnez la quantité de cartes que vous souhaitez dans le champs `PCB Qty`.
1. Laisser toutes les autres options par défaut, puis cliquez sur le toggle switch en face de `PCB Assembly`, et enfin sur le bouton `confirm`.
1. Une preview de la carte électronique sans les composants doit apparaitre. Cliquez sur `NEXT`.
1. Cliquez sur le bouton `Add BOM File`, puis sélectionnez le fichier `bom.csv`
1. Cliquez sur le bouton `Add CPL File`, puis sélectionnez le fichier `pos.csv`
1. **Vérifier que tous les composants sont en stock** et bien sélectionnés, puis cliquez sur `NEXT`.
1. Une preview de la carte avec ses composants apparait. Continuer le chemin en cliquant sur `NEXT`.
1. Le prix final apparait. Sélectionnez la catégorie du produit, puis cliquez sur `SAVE TO CART`.
1. Une fois sauvegardé dans votre panier, vous pouvez valider votre commande et choisir le moyen d'acheminement. Afin de ne pas avoir à se préoccuper des frais de douane, nous vous conseillons de choisir une méthode d'expédition DDP.

Vous receverez vos cartes sous 1 à 3 semaines. 

**Nous ne sommes en aucun cas responsables des cartes qui arriveraient défectueuses ou non fonctionnelles.**

### Modifications des fichiers sources

Installez kicad 6 (ou version supérieure), et ouvrez le fichier LEC009002.kicad_pro

### Programation

Pour programmer le module, vous devez posséder
- un programmateur AVR type USBASP
- Des fils pour relier le programmateur avec les points de programmation. (**Note importante** : cette carte ne possède pas de connecteur de programmation. Pour la programmer, il vous faudra soit utiliser le banc de programmation pour lequel vous souderez des pogo pins, soit trouver un moyen de relier les fils du programmateur à la carte directement)

Le firmware se trouve dans le dossier du même nom. Il est recommandé d'utiliser VS-code et platform-io pour programmer la carte. Pour ce faire, branchez le programmateur à votre PC et à la carte à programmer, puis rentrer les commandes suivantes :

```
cd firmware
platformio run --target fuses && platformio run --target upload
```

### Regénérer les fichiers gerber, BOM, et position (Optionnel)

Peut se faire simplement en utilisant kikit :

```
cd hardware/carte-mere
docker run --rm -w /kikit -v $PWD:/kikit yaqwsx/kikit kikit fab jlcpcb --assembly --no-drc --schematic LEC009002.kicad_sch --field LCSC --corrections JLCPCB_CORRECTION --nametemplate LEC009002_{} LEC009002.kicad_pcb prod/

cd hardware/capteur-droit
docker run --rm -w /kikit -v $PWD:/kikit yaqwsx/kikit kikit fab jlcpcb --assembly --no-drc --schematic LEC009202.kicad_sch --field LCSC --corrections JLCPCB_CORRECTION --nametemplate LEC009202_{} LEC009202.kicad_pcb prod/

cd hardware/capteur-coude
docker run --rm -w /kikit -v $PWD:/kikit yaqwsx/kikit kikit fab jlcpcb --assembly --no-drc --schematic LEC009212.kicad_sch --field LCSC --corrections JLCPCB_CORRECTION --nametemplate LEC009212_{} LEC009212.kicad_pcb prod/
```
## Notices
[Manuel FR](docs/manual_fr.pdf)

## License
Tous nos fichiers sont plubliés sous les licenses
- CERN Open Hardware Licence Version 2 - Strongly Reciprocal pour ce qui touche au hardware
- GNU General Public License v3.0 pour tout ce qui est software

## KiCad design hardware/banc-de-programmation/LEC009-programming-jig.kicad_pcb

Parts:
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3; LCSC DNP
J1: Conn_01x18_Female; PinHeader_1x18_P2.54mm_Vertical
LOGO1: logo_lectix_25mm; Logo_10mm; LCSC DNP
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18: TestPoint_Probe; pogo-1mm; LCSC DNP

Connections:
/+5V: J1.9, TP14.1
/C1: J1.6, TP7.1
/C2: J1.5, TP10.1
/GND: J1.18, TP15.1
/IR_SENSOR: J1.8, TP11.1
/IR_SENSOR_2: J1.16, TP12.1
/MISO: J1.14, TP17.1
/MODE_SENSOR_1: J1.7, TP3.1
/MODE_SENSOR_2: J1.15, TP5.1
/MOSI-IR_LED: J1.17, TP18.1
/PB0: J1.10, TP1.1
/PB1: J1.11, TP2.1
/R1: J1.4, TP6.1
/R2: J1.3, TP9.1
/SCK: J1.13, TP16.1
/T1: J1.2, TP8.1
/T2: J1.1, TP13.1
/nRS: J1.12, TP4.1

Board: 2 copper layers, 69.0 x 50.0 mm, 23 parts (19 on the bottom side), 18 nets.

## KiCad design hardware/capteur-droit/LEC009202.kicad_pcb

Parts:
H1, H2: MountingHole; MountingHole_3.2mm_M3; PartNumber DNP; LCSC DNP
J1: C601936; IDC-Header_2x03_P2.54mm_Vertical; PartNumber 321006SG0ABK00A01; LCSC C601936
JP1: Jumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; PartNumber DNP
LOGO1: logo_lectix_25mm; Logo_10mm; PartNumber DNP; LCSC DNP
U1: DY-ITR20001; DY-ITR20001_edge; MPN DY-ITR20001; LCSC C459137

Connections:
GND: J1.6, JP1.2 (B)
unnamed: J1.1, U1.1 (A)
unnamed: J1.2, U1.2 (K)
unnamed: J1.3, U1.3
unnamed: J1.4, U1.4
unnamed: J1.5, JP1.1 (A)

Notes on the sheet:
CUT JUMPER TO ENABLE ASTABLE MODE

Board: 2 copper layers, 40.0 x 34.0 mm, 8 parts (2 on the bottom side), 6 nets.

Other parts of the board:
kibuzzard-620CD483: G***; kibuzzard-620CD483
kibuzzard-6239F921: G***; kibuzzard-6239F921

## KiCad design hardware/carte-mere/LEC009002.kicad_pcb

Parts:
C1, C3, C4: 100nF; C_0603_1608Metric; LCSC C14663
C2, C5: 100uF; CP_Elec_6.3x5.8; LCSC C249982
D1: MB10S; TO-269AA; LCSC C2488
D2: LED; LED_0603_1608Metric; LCSC C72043
D3: D; D_SMA; LCSC C95872
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3; LCSC DNP
J1: PWR; TerminalBlock_bornier-2_P5.08mm-green; LCSC C395849
J3: CONTACT_1; TerminalBlock_bornier-3_P5.08mm-blue; LCSC C395881
J4: CONTACT2; TerminalBlock_bornier-3_P5.08mm-blue; LCSC C395881
J5, J6: IDC6; IDC-Header_2x03_P2.54mm_Vertical; LCSC C11214
K1: HK19F-5V; Relay_DPDT_HK19F; LCSC C54512
LOGO1: logo_lectix_25mm; Logo_10mm; LCSC DNP
Q1, Q2, Q3: S8050; SOT-23; LCSC C2146
R1, R5: 10k; R_0603_1608Metric; LCSC C25804
R2, R3, R4, R8, R9: 1k; R_0603_1608Metric; LCSC C21190
R6, R7: 100; R_0603_1608Metric; LCSC C22775
RV1, RV2: 100k; Potentiometer_Bourns_TC33X_Vertical; LCSC C128545
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18: TestPoint_Probe; TestPoint_Pad_D1.5mm; LCSC DNP
U1: ATtiny24A-SSU; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C8726
U2: MC78M05_TO252; TO-252-2; LCSC C58069

Connections:
+5V: C1.1, C4.1, C5.1, D2.2 (A), D3.1 (K), K1.1, R1.1, R6.1, R7.1, RV1.3, RV2.3, TP14.1, U1.1 (VCC), U2.3 (VO)
/C1: J3.3, K1.4, TP7.1
/C2: J4.1, K1.13, TP10.1
/IR_LED_2: R4.2, U1.5 (PB2)
/IR_SENSOR: J5.4, RV1.1, RV1.2, TP11.1, U1.11 (PA2)
/IR_SENSOR_2: J6.4, RV2.1, RV2.2, TP12.1, U1.6 (PA7)
/MISO: TP17.1, U1.8 (PA5)
/MODE_SENSOR_1: J5.5, TP3.1, U1.13 (AREF/PA0)
/MODE_SENSOR_2: J6.5, TP5.1, U1.12 (PA1)
/MOSI-IR_LED: R3.2, TP18.1, U1.7 (PA6)
/R1: J3.2, K1.6, TP6.1
/R2: J4.2, K1.11, TP9.1
/RELAY: R2.2, U1.10 (PA3)
/SCK: TP16.1, U1.9 (PA4)
/T1: J3.1, K1.8, TP8.1
/T2: J4.3, K1.9, TP13.1
/nRS: R1.2, TP4.1, U1.4 (~RESET/PB3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.2 (-), J5.6, J6.6, Q1.2 (E), Q2.2 (E), Q3.2 (E), R8.1, R9.1, TP15.1, U1.14 (GND), U2.2 (GND)
unnamed: C2.1, C3.1, D1.1 (+), U2.1 (VI)
unnamed: D1.3, J1.1
unnamed: D1.4, J1.2
unnamed: D2.1 (K), R5.2
unnamed: D3.2 (A), K1.16, Q1.3 (C), R5.1
unnamed: J5.1, R6.2
unnamed: J5.2, Q2.3 (C)
unnamed: J5.3, R8.2
unnamed: J6.1, R7.2
unnamed: J6.2, Q3.3 (C)
unnamed: J6.3, R9.2
unnamed: Q1.1 (B), R2.1
unnamed: Q2.1 (B), R3.1
unnamed: Q3.1 (B), R4.1
unnamed: TP1.1, U1.2 (XTAL1/PB0)
unnamed: TP2.1, U1.3 (XTAL2/PB1)

Notes on the sheet:
Chose the sensitivity level

Board: 2 copper layers, 69.0 x 32.0 mm, 52 parts (18 on the bottom side), 34 nets.

File hardware/carte-mere/prod/LEC009002_bom.csv:

Comment,Designator,Footprint,LCSC
100nF,"C1,C3,C4",Capacitor_SMD:C_0603_1608Metric,C14663
100uF,"C2,C5",0_capacitors:CP_Elec_6.3x5.8,C249982
MB10S,D1,Package_TO_SOT_SMD:TO-269AA,C2488
LED,D2,LED_SMD:LED_0603_1608Metric,C72043
D,D3,Diode_SMD:D_SMA,C95872
PWR,J1,0_connectors:TerminalBlock_bornier-2_P5.08mm-green,C395849
CONTACT_1,J3,0_connectors:TerminalBlock_bornier-3_P5.08mm-blue,C395881
CONTACT2,J4,0_connectors:TerminalBlock_bornier-3_P5.08mm-blue,C395881
IDC6,"J5,J6",Connector_IDC:IDC-Header_2x03_P2.54mm_Vertical,C11214
HK19F-5V,K1,0_relays:Relay_DPDT_HK19F,C54512
S8050,"Q1,Q2,Q3",Package_TO_SOT_SMD:SOT-23,C2146
10k,"R1,R5",Resistor_SMD:R_0603_1608Metric,C25804
1k,"R2,R3,R4,R8,R9",Resistor_SMD:R_0603_1608Metric,C21190
100,"R6,R7",Resistor_SMD:R_0603_1608Metric,C22775
100k,"RV1,RV2",0_potentiometers:Potentiometer_Bourns_TC33X_Vertical,C128545
ATtiny24A-SSU,U1,Package_SO:SOIC-14_3.9x8.7mm_P1.27mm,C8726
MC78M05_TO252,U2,Package_TO_SOT_SMD:TO-252-2,C58069

## Code that names these connections

File firmware/src/constants.h:

#ifndef CONSTANTS_H
#define CONSTANTS_H

#define MODE_1_SENSOR_TIMEOUT 1000 /* timeout in ms */
#define MODE_2_SENSOR_TIMEOUT 1000 /* timeout in ms */

#define PIN_IR_LED_1 4
#define PIN_IR_SENSOR_2 3
#define PIN_SENSOR1_MODE 10
#define PIN_SENSOR2_MODE 9
#define PIN_IR_SENSOR_1 8
#define PIN_IR_LED_2 2
#define PIN_RELAY 7

#endif

## Commit log

2023-04-24 Add manual
2023-04-24 Add firmware
2023-05-05 Add hardware source files
2023-05-05 Add programming jig
